# IAR project test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F303xC GigaDevice GD32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: GD32F30X_HD
  ICCARM.CCIncludePath2: CMSIS_GD\GD\GD32F30x\Include; CMSIS_GD\GD\GD32F30x\Source\IAR; CMSIS_GD; driver_GD\src; driver_GD\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: test.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ./: main.c oled.c st7735.c
  group CMSIS
    CMSIS_GD/GD/GD32F30x/Include/: gd32f30x.h
    CMSIS_GD/GD/GD32F30x/Source/IAR/: startup_gd32f30x_hd.s
    CMSIS_GD/GD/GD32F30x/Source/: system_gd32f30x.c
  group DRIVER
    ./: gd32f30x.h system_gd32f30x.h
    driver_GD/src/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
    driver_GD/inc/: gd32f30x_adc.h gd32f30x_bkp.h gd32f30x_can.h gd32f30x_crc.h gd32f30x_ctc.h gd32f30x_dac.h gd32f30x_dbg.h gd32f30x_dma.h gd32f30x_enet.h gd32f30x_exmc.h gd32f30x_exti.h gd32f30x_fmc.h gd32f30x_fwdgt.h gd32f30x_gpio.h gd32f30x_i2c.h gd32f30x_libopt.h gd32f30x_misc.h gd32f30x_pmu.h gd32f30x_rcu.h gd32f30x_rtc.h gd32f30x_sdio.h gd32f30x_spi.h gd32f30x_timer.h gd32f30x_usart.h gd32f30x_wwdgt.h
